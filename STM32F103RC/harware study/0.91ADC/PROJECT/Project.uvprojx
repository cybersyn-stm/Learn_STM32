# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99 -D__MICROLIB
  c include: ..\CMSIS;..\USER;..\FWLIB\inc;..\DRIVE;..\u8g2;..\STARTUP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c
  group FWILB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/: startup_stm32f10x_md.s
  group DRIVE
    ../DRIVE/: GPIO.c RCC.c USART.c ADC.c TIM.c TIM_Register.c U8G2_USER.c
  group U8G2
    ../u8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
    ../../../../../u8g2-master/csrc/: u8x8_d_ssd1306_128x64_noname.c
